Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Jonas\Documents\Cadfocus\Ostnor\2012\CAD-objekt_2012-09-28\CADFOCUS\241200\AutoCAD Architecture\241200.ifc
Time: 2012-10-16T16:57:08
Author: - -
Organization: Mora Armatur, Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 241200
LongName: 241200
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 241200
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 241200, BUILDINGELEMENTPROXY(1)
In: 241200
Description: Mora Cera T4 Mixer For Shower 40 c/c chrome
